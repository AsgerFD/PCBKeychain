# Repository AsgerFD/PCBKeychain

File README.md:

# PCBKeychain
A keychain with the outline of Miku
It should be able to light up and vibrate as a thing to toy with.
# BOM
- 1 Battery Holder
- 1 220 Ohm Resistors
- 1 Potentiometer
- 1 Motor
- 2 Push Buttons
- 2 LEDs
# Screenshots

Made by @Asger Fuglsbjerg on Slack

## KiCad design src/solder.kicad_pcb

Parts:
BT1: Battery_Cell; BatteryHolder_Keystone_3034_1x20mm
D1, D2: LED; LED_D5.0mm
M1: Motor_DC; PinHeader_1x02_P2.54mm_Vertical
R1: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
RV1: R_Potentiometer; Potentiometer_Vishay_T73YP_Vertical
SW1, SW2: SW_Push; SW_PUSH_6mm

Connections:
unnamed: BT1.1 (+), SW1.2, SW2.2
unnamed: BT1.2 (-), D1.1 (K), D2.1 (K), M1.2 (-)
unnamed: D1.2 (A), D2.2 (A), R1.2
unnamed: M1.1 (+), RV1.2
unnamed: R1.1, SW1.1
unnamed: RV1.3, SW2.1

Board: 2 copper layers, 60.2 x 92.3 mm, 8 parts (0 on the bottom side), 6 nets.

## Commit log

2025-05-03 Uploading files
2025-05-03 Minor change
2025-05-03 Rework
2025-05-03 Added keychain hole
2025-05-04 Reversed battery
2025-05-04 Miku on b_silkscreen
2025-05-04 Changed so the variable resistor is variable
2025-05-04 Rewired the motor
2025-05-04 Extra commit
